FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# Set HOSTNAME
hostname = "autoscope"
