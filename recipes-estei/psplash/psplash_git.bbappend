FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
# SPLASH_IMAGES_append_start = " file://psplash-start-img.h;outsuffix=start"
# ALTERNATIVE_PRIORITY_psplash-start[psplash] = "6"
