FILESEXTRAPATHS_prepend := "${THISDIR}/wpa-supplicant:"

# SRC_URI += "file://wpa_supplicant.conf"
#
# do_install_append() {
# install -d ${D}${sysconfdir}/wpa_supplicant
# install -m 0755 ${WORKDIR}/wpa_supplicant.conf 
#     ${D}${sysconfdir}/wpa_supplicant
# }
