SUMMARY = "Poky image"

DESCRIPTION = "Autoscope linux system configuration"

LICENSE = "GPLv2"

# Minimal image providing a console only
inherit core-image
